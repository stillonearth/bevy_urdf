Commit message: wip

File: assets/robots/unitree_a1/urdf/a1.urdf (robot description, URDF)
Before this commit: robot a1, 23 links, 22 joints
Links:
- removed link base
Joints:
- removed joint floating_base
